# Keil uVision project modbus_master.uvprojx, settings and files
target modbus_master (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: modbus_master
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;   ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Drivers/CMSIS/Include;   ../Middlewares/Third_Party/FreeModbus/modbus/include;   ../Middlewares/Third_Party/FreeModbus/modbus/ascii;   ../Middlewares/Third_Party/FreeModbus/modbus/rtu;   ../Middlewares/Third_Party/FreeModbus/modbus/tcp;   ../Middlewares/Third_Party/FreeModbus/port
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c queue.c list.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FreeModBus
    ../Middlewares/Third_Party/FreeModbus/modbus/ascii/: mbascii.c
    ../Middlewares/Third_Party/FreeModbus/modbus/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
    ../Middlewares/Third_Party/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c mbrtu_m.c
    ../Middlewares/Third_Party/FreeModbus/modbus/tcp/: mbtcp.c
    ../Middlewares/Third_Party/FreeModbus/modbus/: mb.c mb_m.c
    ../Middlewares/Third_Party/FreeModbus/port/: user_mb_app.c user_mb_app_m.c
    ../Middlewares/Third_Party/FreeModbus/port/rtt/: port.c portevent.c portevent_m.c portserial.c portserial_m.c porttimer.c porttimer_m.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c gpio.c freertos.c stm32l4xx_it.c tim.c usart.c main.c modbus_example.c
software components: CMSIS:CORE 4.3.0
