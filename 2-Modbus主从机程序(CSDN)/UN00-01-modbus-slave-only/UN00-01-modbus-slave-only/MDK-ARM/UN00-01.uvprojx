# Keil uVision project UN00-01.uvprojx, settings and files
target UN00-01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: UN00-01
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c include: ../Inc;       ../Drivers/STM32L0xx_HAL_Driver/Inc;       ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;       ../Drivers/CMSIS/Include;   ../Additional/freemodbus/modbus/include;    ../Additional/freemodbus/modbus/port;   ../Additional/freemodbus/modbus/rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_pwr.c stm32l0xx_hal_spi.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_flash.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_uart_ex.c
  group Application/User
    ../Src/: gpio.c main.c spi.c usart.c stm32l0xx_it.c tim.c stm32l0xx_hal_msp.c dma.c iwdg.c
  group Application/UNXX
    ../Src/: cp2102.c debug.c led.c
  group ModBus
    ../Additional/freemodbus/modbus/port/: mbcrc.c portevent.c portserial.c porttimer.c
    ../Additional/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Additional/freemodbus/modbus/: mb.c
    ../Additional/freemodbus/modbus/rtu/: mbrtu.c
software components: CMSIS:CORE 4.3.0
